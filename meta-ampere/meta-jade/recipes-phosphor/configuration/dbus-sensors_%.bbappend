PACKAGECONFIG:append = " amperecpusensor"
PACKAGECONFIG:remove = " intrusionsensor"
