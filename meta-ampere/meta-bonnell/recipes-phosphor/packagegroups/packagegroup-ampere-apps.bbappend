RDEPENDS:${PN}-system:append = "ampere-misc"
