FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
PACKAGECONFIG = "abi-development"

SRCREV = "98e137dede322e3fb6c390bacdc8692441149104"
