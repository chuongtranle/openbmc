SRC_URI = " \
           git://github.com/ampere-openbmc/linux;protocol=https;branch=ampere \
           file://defconfig \
          "

SRCREV="606a66d7a7ad773e418d6220ddb571695b3dc523"
