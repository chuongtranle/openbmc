SRCREV = "${AUTOREV}"
UBRANCH = "ampere-next"
SRC_URI = "git://github.com/ampere-openbmc/u-boot.git;branch=${UBRANCH};protocol=git"
